# Keil uVision project Blinking_Led.uvprojx, settings and files
target Target (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinking_LED
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\COTS\LIB;.\COTS\MCAL\MCU;.\COTS\MCAL\IntCtrl;.\COTS\MCAL\DIO
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group DIO
    ./COTS/MCAL/DIO/: DIO_Program.c
  group MCU
    ./COTS/MCAL/MCU/: MCU_Program.c
  group IntCtrl
    ./COTS/MCAL/IntCtrl/: IntCtrl_Lcfg.c IntCtrl_Program.c
  group GPTM
    ./: GPTM_Program.c GPTM_Interface.h GPTM_Registers.h GPTM_CFG.h
  group APP
    ./: APP.c APP.h
  group Main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
